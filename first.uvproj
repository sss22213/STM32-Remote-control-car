# Keil uVision project first.uvproj, settings and files
target first (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: first +hex
  c flags: Optim=1
  c include: ..\STM32_FW;.\user;.\user\MPU6050
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group boot
    ./: STM32F10x.s
  group library
    ./library/src/: stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_nvic.c stm32f10x_tim.c stm32f10x_systick.c stm32f10x_exti.c stm32f10x_i2c.c
    ../STM32_FW/library/src/: stm32f10x_flash.c
  group interrupt
    ./interrupt/: stm32f10x_it.c stm32f10x_it.h
  group src
    ./library/src/: main.c
    ./library/inc/: main.h
  group user
    ./user/: AT24C02.c AT24C02.h Delay.c Delay.h I2C.c I2C.h USART.c USART.h
  group MPU6050_DMP
    ./user/MPU6050/: anbt_dmp_driver.c anbt_dmp_driver.h anbt_dmp_fun.h anbt_dmp_mpu6050.c anbt_dmp_mpu6050.h anbt_i2c.c anbt_i2c.h
